options:
  parameters:
    generate_options: qt_gui
    id: dish_control
    output_language: python
    qt_qss_theme: qss_file
    title: CARP Observatory Manual Control
  states: {}

blocks:
- name: az_speed
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,2,1,2
    label: AZIM SPEED
    start: '0'
    step: '50'
    stop: '1600'
    value: '50'
  states: {}
- name: azim_east
  id: variable_qtgui_push_button
  parameters:
    gui_hint: 1,1,1,1
    label: EAST
    pressed: '1'
    released: '0'
    type: int
    value: '0'
  states: {}
- name: azim_east_status
  id: variable
  parameters:
    value: dish_funcs.azim_east(azim_east,az_speed,motor_xml)
  states: {}
- name: azim_west
  id: variable_qtgui_push_button
  parameters:
    gui_hint: 1,0,1,1
    label: WEST
    pressed: '1'
    released: '0'
    type: int
    value: '0'
  states: {}
- name: azim_west_status
  id: variable
  parameters:
    value: dish_funcs.azim_west(azim_west,az_speed,motor_xml)
  states: {}
- name: el_speed
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,2,1,2
    label: ELEV SPEED
    start: '0'
    step: '50'
    stop: '1600'
    value: '50'
  states: {}
- name: elev_dn_status
  id: variable
  parameters:
    value: dish_funcs.elev_down(elev_down,el_speed,motor_xml)
  states: {}
- name: elev_down
  id: variable_qtgui_push_button
  parameters:
    gui_hint: 0,1,1,1
    label: DOWN
    pressed: '1'
    released: '0'
    type: int
    value: '0'
  states: {}
- name: elev_up
  id: variable_qtgui_push_button
  parameters:
    gui_hint: 0,0,1,1
    label: UP
    pressed: '1'
    released: '0'
    type: int
    value: '0'
  states: {}
- name: elev_up_status
  id: variable
  parameters:
    value: dish_funcs.elev_up(elev_up,el_speed,motor_xml)
  states: {}
- name: exit_status
  id: variable
  parameters:
    value: dish_funcs.sysExit(shutdown,motor_xml)
  states: {}
- name: heartbeat_status
  id: variable
  parameters:
    value: dish_funcs.do_heartbeat(slow_pacer,[elev_up,elev_down,azim_east,azim_west])
  states: {}
- name: limit_status
  id: variable
  parameters:
    value: dish_funcs.ResetLimits(limits,motor_xml)
  states: {}
- name: limits
  id: variable_qtgui_push_button
  parameters:
    gui_hint: 7,2,1,1
    label: '>>>>RESET LIMITS<<<'
    pressed: '1'
    released: '0'
    type: int
    value: '0'
  states: {}
- name: pacer
  id: variable_function_probe
  parameters:
    block_id: pacer_probe
    function_name: level
    poll_rate: 1.0/scadence
    value: '0'
  states: {}
- name: posns
  id: variable
  parameters:
    value: dish_funcs.get_posns(pacer,sensor_xml)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '16000'
  states: {}
- name: shutdown
  id: variable_qtgui_push_button
  parameters:
    gui_hint: 7,0,1,1
    label: '>>>EXIT MOTOR SRVR<<<'
    pressed: '1'
    released: '0'
    type: int
    value: '0'
  states: {}
- name: slow_pacer
  id: variable_function_probe
  parameters:
    block_id: pacer_probe
    function_name: level
    poll_rate: 1.0/10.0
    value: '0'
  states: {}
- name: variable_qtgui_label_0
  id: variable_qtgui_label
  parameters:
    gui_hint: 2,0,1,1
    label: 'ELEVATION:'
    type: string
    value: '"%5.2f" % posns[0]'
  states: {}
- name: variable_qtgui_label_0_0
  id: variable_qtgui_label
  parameters:
    gui_hint: 2,2,1,1
    label: 'AZIMUTH:'
    type: string
    value: '"%5.2f" % posns[1]'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_CONST_WAVE
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: 'pmt.cons(pmt.to_pmt({"az": posns[1], "el": posns[0]}),pmt.to_pmt(None))'
    period: '1000'
  states: {state: disabled}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: dish_funcs
  id: epy_module
  parameters:
    source_code: |
      # this module will be imported in the into your flowgraph
      import time
      import numpy
      import os
      import sys
      import xmlrpc.client as xml
      import time

      RPC = None
      RPC2 = None

      def init_RPC(srvr):
          global RPC
          if (RPC == None):
              try:
                  RPC = xml.ServerProxy(srvr)
              except:
                  RPC = None

      def sysExit(v,srvr):
          global RPC
          init_RPC(srvr)
          
          if (v == 1):
              try:
                  RPC.SysExit(0)
              except:
                  pass
          
      def init_RPC2(srvr):
          global RPC2
          if (RPC2 == None):
              RPC2 = xml.ServerProxy(srvr)

      def ResetLimits(btn,srvr):
          if (btn == 1):
              axLimits(0,srvr)
              time.sleep(0.25)
              axLimits(1,srvr)
             
      def axLimits(ax,srvr):
          global RPC
          init_RPC(srvr)
          try:
              RPC.AccLimit(ax, 1000)
              time.sleep(0.25)
              RPC.VelLimit(ax, 1600)
              rv = True
          except:
              rv = False
          return rv

      def tryMove(lbl, ax,spd):
          global RPC
          try:
              RPC.HeartBeat(0)
              time.sleep(0.333)
              RPC.Move(ax,spd)
          except:
              print ("Exception in move on axis %d/%f" % (ax, spd))
              pass

      upstate = 0
      def elev_up(up,speed,srvr):
          global RPC
          global upstate

          init_RPC(srvr)
          if (RPC != None):
              if (upstate != up):
                  upstate = up
                  if (up == 1):
                      tryMove("Up", 0,speed)
                  if (up == 0):
                      tryMove("Up", 0,0.0)
                  
      downstate = 0          
      def elev_down(down,speed,srvr):
          global RPC
          global downstate

          init_RPC(srvr)
          if (RPC != None):
              if (down != downstate):
                  downstate = down
                  if (down == 1):
                      tryMove("Down", 0,-1.0*speed)
                  if (down == 0):
                      tryMove("Down", 0,0.0)
      weststate = 0               
      def azim_west(west,speed,srvr):
          global RPC
          global weststate
          init_RPC(srvr)
          if (RPC != None):
              if (weststate != west):
                  weststate = west
                  if (west == 1):
                      tryMove("West", 1, speed)
                  if (west == 0):
                      tryMove("West", 1, 0.0)
      eaststate = 0
      def azim_east(east,speed,srvr):
          global RPC
          global eaststate
          init_RPC(srvr)
          if (RPC != None):
              if (eaststate != east):
                  eaststate = east
                  if (east == 1):
                      tryMove("East", 1, -1.0*speed)
                  if (east == 0):
                      tryMove("East", 1, 0.0)

      def get_posns(pacer,srvr):
          global RPC2
          init_RPC2(srvr)
          try:
              posns = RPC2.query_both_axes()
          except:
              #print ("get_posns called, but exception was raised")
              posns = (-1000, -1000)
          return(posns)

      def do_heartbeat(pacer,buttons):
          global RPC
          print ("Trying heartbeat")
          if (1 in buttons):
              print ("Actually trying")
              try:
                  RPC.HeartBeat(0)
              except:
                  pass
          return 1
  states: {}
- name: import_55
  id: import
  parameters:
    imports: import os
  states: {}
- name: motor_xml
  id: parameter
  parameters:
    label: URL for motor server
    type: str
    value: '"http://localhost:36036"'
  states: {}
- name: pacer_probe
  id: blocks_probe_signal_x
  parameters:
    type: float
  states: {}
- name: qss_file
  id: parameter
  parameters:
    label: QSS FILE
    type: str
    value: os.environ['HOME']+"/.qt/"+"dish_ctl.qss"
  states: {}
- name: scadence
  id: parameter
  parameters:
    label: Cadence of sensor query, in seconds
    type: eng_float
    value: '1.0'
  states: {}
- name: sensor_xml
  id: parameter
  parameters:
    label: URL for sensor server
    type: str
    value: '"http://localhost:9090"'
  states: {}
- name: snippet_0
  id: snippet
  parameters:
    code: |-
      dish_funcs.axLimits(0,self.motor_xml)
      dish_funcs.axLimits(1,self.motor_xml)
    section: main_after_init
  states: {}
- name: variable_qtgui_azelplot_0
  id: variable_qtgui_azelplot
  parameters:
    gui_hint: 3,0,3,4
    label: '"Telescope  Position\n                NORTH"'
  states: {state: disabled}

connections:
- [analog_sig_source_x_0, '0', blocks_throttle_0, '0']
- [blocks_message_strobe_0, strobe, variable_qtgui_azelplot_0, azel]
- [blocks_throttle_0, '0', pacer_probe, '0']

metadata:
  file_format: 1
