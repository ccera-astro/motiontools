options:
  parameters:
    generate_options: qt_gui
    id: dish_control
    output_language: python
    title: CARP Observatory Manual Control
  states: {}

blocks:
- name: az_speed
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,2,1,1
    label: AZIM SPEED
    start: '50'
    step: '25'
    stop: '500'
    value: '50'
  states: {}
- name: azim_east
  id: variable_qtgui_push_button
  parameters:
    gui_hint: 1,1,1,1
    label: EAST
    pressed: '1'
    released: '0'
    type: int
    value: '0'
  states: {}
- name: azim_west
  id: variable_qtgui_push_button
  parameters:
    gui_hint: 1,0,1,1
    label: WEST
    pressed: '1'
    released: '0'
    type: int
    value: '0'
  states: {}
- name: azim_west_status_0_0
  id: variable
  parameters:
    value: dish_funcs.azim_west(azim_west,az_speed)
  states: {}
- name: azim_west_status_0_0_0
  id: variable
  parameters:
    value: dish_funcs.azim_east(azim_east,az_speed)
  states: {}
- name: el_speed
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,2,1,1
    label: ELEV SPEED
    start: '50'
    step: '25'
    stop: '500'
    value: '50'
  states: {}
- name: elev_dn_status_0
  id: variable
  parameters:
    value: dish_funcs.elev_down(elev_down,el_speed)
  states: {}
- name: elev_down
  id: variable_qtgui_push_button
  parameters:
    gui_hint: 0,1,1,1
    label: DOWN
    pressed: '1'
    released: '0'
    type: int
    value: '0'
  states: {}
- name: elev_up
  id: variable_qtgui_push_button
  parameters:
    gui_hint: 0,0,1,1
    label: UP
    pressed: '1'
    released: '0'
    type: int
    value: '0'
  states: {}
- name: elev_up_status
  id: variable
  parameters:
    value: dish_funcs.elev_up(elev_up,el_speed)
  states: {}
- name: pacer
  id: variable_function_probe
  parameters:
    block_id: pacer_probe
    function_name: level
    poll_rate: '2.0'
    value: '0'
  states: {}
- name: posns
  id: variable
  parameters:
    value: dish_funcs.get_posns(pacer)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '16000'
  states: {}
- name: variable_qtgui_label_0
  id: variable_qtgui_label
  parameters:
    label: ELEVATION
    type: string
    value: '"%5.2f" % posns[0]'
  states: {}
- name: variable_qtgui_label_0_0
  id: variable_qtgui_label
  parameters:
    label: AZIMUTH
    type: string
    value: '"%5.2f" % posns[1]'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_CONST_WAVE
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: 'pmt.cons(pmt.to_pmt({"az": posns[1], "el": posns[0]}),pmt.to_pmt(None))'
    period: '250'
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: dish_funcs
  id: epy_module
  parameters:
    source_code: |
      # this module will be imported in the into your flowgraph
      import time
      import numpy
      import os
      import sys
      import xmlrpc.client as xml

      RPC = None
      RPC2 = None

      def init_RPC():
          global RPC
          global RPC2
          if (RPC == None):
              try:
                  RPC = xml.ServerProxy("http://localhost:36036")
              except:
                  RPC = None
          if (RPC2 == None):
              try:
                  RPC2 = xml.ServerProxy("http://localhost:9090")
              except:
                  RPC2 = None

      def tryMove(lbl, ax,spd):
          try:
              RPC.Move(ax,spd)
          except:
              pass

      upstate = 0
      def elev_up(up,speed):
          global RPC
          global upstate

          init_RPC()
          if (RPC != None):
              if (upstate != up):
                  upstate = up
                  if (up == 1):
                      tryMove("Up", 0,speed)
                  if (up == 0):
                      tryMove("Up", 0,0.0)
                  
      downstate = 0          
      def elev_down(down,speed):
          global RPC
          global downstate

          init_RPC()
          if (RPC != None):
              if (down != downstate):
                  downstate = down
                  if (down == 1):
                      tryMove("Down", 0,-1.0*speed)
                  if (down == 0):
                      tryMove("Down", 0,0.0)
      weststate = 0               
      def azim_west(west,speed):
          global RPC
          global weststate
          init_RPC()
          if (RPC != None):
              if (weststate != west):
                  weststate = west
                  if (west == 1):
                      tryMove("West", 1, speed)
                  if (west == 0):
                      tryMove("West", 1, 0.0)
      eaststate = 0
      def azim_east(east,speed):
          global RPC
          global eaststate
          init_RPC()
          if (RPC != None):
              if (eaststate != east):
                  eaststate = east
                  if (east == 1):
                      tryMove("East", 1, -1.0*speed)
                  if (east == 0):
                      tryMove("East", 1, 0.0)

      def get_posns(pacer):
          global RPC2
          init_RPC()
          try:
              posns = RPC2.get_both_axes()
          except:
              posns = (-1000, -1000)
          return(posns)
  states: {}
- name: pacer_probe
  id: blocks_probe_signal_x
  parameters:
    type: float
  states: {}
- name: variable_qtgui_azelplot_0
  id: variable_qtgui_azelplot
  parameters:
    label: TELESCOPE POSITION
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_throttle_0, '0']
- [blocks_message_strobe_0, strobe, variable_qtgui_azelplot_0, azel]
- [blocks_throttle_0, '0', pacer_probe, '0']

metadata:
  file_format: 1
