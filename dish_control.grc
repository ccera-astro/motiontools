options:
  parameters:
    generate_options: qt_gui
    id: dish_control
    output_language: python
    qt_qss_theme: qss_file
    title: CARP Observatory Manual Control
  states: {}

blocks:
- name: az_speed
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,2,1,2
    label: AZIM SPEED
    start: '0'
    step: '50'
    stop: '1600'
    value: '50'
  states: {}
- name: azim_east
  id: variable_qtgui_push_button
  parameters:
    gui_hint: 1,1,1,1
    label: EAST
    pressed: '1'
    released: '0'
    type: int
    value: '0'
  states: {}
- name: azim_east_status
  id: variable
  parameters:
    value: dish_funcs.azim_east(azim_east,az_speed,motor_xml)
  states: {}
- name: azim_west
  id: variable_qtgui_push_button
  parameters:
    gui_hint: 1,0,1,1
    label: WEST
    pressed: '1'
    released: '0'
    type: int
    value: '0'
  states: {}
- name: azim_west_status
  id: variable
  parameters:
    value: dish_funcs.azim_west(azim_west,az_speed,motor_xml)
  states: {}
- name: el_speed
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,2,1,2
    label: ELEV SPEED
    start: '0'
    step: '50'
    stop: '1600'
    value: '50'
  states: {}
- name: elev_dn_status
  id: variable
  parameters:
    value: dish_funcs.elev_down(elev_down,el_speed,motor_xml)
  states: {}
- name: elev_down
  id: variable_qtgui_push_button
  parameters:
    gui_hint: 0,1,1,1
    label: DOWN
    pressed: '1'
    released: '0'
    type: int
    value: '0'
  states: {}
- name: elev_up
  id: variable_qtgui_push_button
  parameters:
    gui_hint: 0,0,1,1
    label: UP
    pressed: '1'
    released: '0'
    type: int
    value: '0'
  states: {}
- name: elev_up_status
  id: variable
  parameters:
    value: dish_funcs.elev_up(elev_up,el_speed,motor_xml)
  states: {}
- name: exit_status
  id: variable
  parameters:
    value: dish_funcs.sysExit(shutdown,motor_xml)
  states: {}
- name: heartbeat_status
  id: variable
  parameters:
    value: dish_funcs.do_heartbeat(slow_pacer,[elev_up,elev_down,azim_east,azim_west])
  states: {}
- name: limit_status
  id: variable
  parameters:
    value: dish_funcs.ResetLimits(limits,motor_xml)
  states: {}
- name: limits
  id: variable_qtgui_push_button
  parameters:
    gui_hint: 7,1,1,1
    label: '>>>>RESET LIMITS<<<'
    pressed: '1'
    released: '0'
    type: int
    value: '0'
  states: {}
- name: pacer
  id: variable_function_probe
  parameters:
    block_id: pacer_probe
    function_name: level
    poll_rate: 1.0/scadence
    value: '0'
  states: {}
- name: posns
  id: variable
  parameters:
    value: dish_funcs.get_posns(pacer,sensor_xml)
  states: {}
- name: pwr_off_status
  id: variable
  parameters:
    value: dish_funcs.pwr_off(sys_pwr_off,pwr_address)
  states: {}
- name: pwr_on_status
  id: variable
  parameters:
    value: dish_funcs.pwr_on(sys_pwr_on,pwr_address)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '16000'
  states: {}
- name: shutdown
  id: variable_qtgui_push_button
  parameters:
    gui_hint: 7,0,1,1
    label: '>>>EXIT MOTOR SRVR<<<'
    pressed: '1'
    released: '0'
    type: int
    value: '0'
  states: {}
- name: slow_pacer
  id: variable_function_probe
  parameters:
    block_id: pacer_probe
    function_name: level
    poll_rate: 1.0/10.0
    value: '0'
  states: {}
- name: sys_pwr_off
  id: variable_qtgui_push_button
  parameters:
    gui_hint: 8,1,1,1
    label: '>>>>SYS PWR OFF<<<<'
    pressed: '1'
    released: '0'
    type: int
    value: '0'
  states: {}
- name: sys_pwr_on
  id: variable_qtgui_push_button
  parameters:
    gui_hint: 8,0,1,1
    label: '>>>>SYS PWR ON<<<<'
    pressed: '1'
    released: '0'
    type: int
    value: '0'
  states: {}
- name: variable_qtgui_label_0
  id: variable_qtgui_label
  parameters:
    gui_hint: 2,0,1,1
    label: 'ELEVATION:'
    type: string
    value: '"%5.2f" % posns[0]'
  states: {}
- name: variable_qtgui_label_0_0
  id: variable_qtgui_label
  parameters:
    gui_hint: 2,2,1,1
    label: 'AZIMUTH:'
    type: string
    value: '"%5.2f" % posns[1]'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_CONST_WAVE
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: 'pmt.cons(pmt.to_pmt({"az": posns[1], "el": posns[0]}),pmt.to_pmt(None))'
    period: '1000'
  states: {state: disabled}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: dish_funcs
  id: epy_module
  parameters:
    source_code: "# this module will be imported in the into your flowgraph\nimport time\nimport numpy\nimport os\nimport sys\nimport xmlrpc.client as xml\nimport time\n\nRPC = None\nRPC2 = None\n\nInitReset = False\n\ndef init_RPC(srvr):\n    global RPC\n    global InitReset\n    if (RPC == None):\n        try:\n            RPC = xml.ServerProxy(srvr)\n        except:\n            RPC = None\n    if (RPC is not None and InitReset is False):\n        try:\n            RPC.AccLimit(0, 2200)\n            time.sleep(0.25)\n            RPC.VelLimit(0, 1600)\n            time.sleep(0.5)\n            RPC.AccLimit(1, 2200)\n            time.sleep(0.25)\n            RPC.VelLimit(1, 1600)\n        except:\n            pass\n\ndef sysExit(v,srvr):\n    global RPC\n    init_RPC(srvr)\n    \n    if (v == 1):\n        try:\n            RPC.SysExit(0)\n        except:\n            pass\n    \ndef init_RPC2(srvr):\n    global RPC2\n    if (RPC2 == None):\n        RPC2 = xml.ServerProxy(srvr)\n\ndef ResetLimits(btn,srvr):\n    if (btn == 1):\n        axLimits(0,srvr)\n        time.sleep(0.25)\n        axLimits(1,srvr)\n       \ndef axLimits(ax,srvr):\n    global RPC\n    init_RPC(srvr)\n    try:\n        RPC.AccLimit(ax, 2200)\n        time.sleep(0.25)\n        RPC.VelLimit(ax, 1600)\n        rv = True\n    except:\n        rv = False\n    return rv\n\ndef tryMove(lbl, ax,spd):\n    global RPC\n    try:\n        RPC.HeartBeat(0)\n        time.sleep(0.333)\n        RPC.Move(ax,spd)\n    except:\n        print (\"Exception in move on axis %d/%f\" % (ax, spd))\n        pass\n\nupstate = 0\ndef elev_up(up,speed,srvr):\n    global RPC\n    global upstate\n\n    init_RPC(srvr)\n    if (RPC != None):\n        if (upstate != up):\n            upstate = up\n            if (up == 1):\n                tryMove(\"Up\", 0,speed)\n            if (up == 0):\n                tryMove(\"Up\", 0,0.0)\n            \ndownstate = 0          \ndef elev_down(down,speed,srvr):\n    global RPC\n    global downstate\n\n    init_RPC(srvr)\n    if (RPC != None):\n        if (down != downstate):\n            downstate = down\n            if (down == 1):\n                tryMove(\"Down\", 0,-1.0*speed)\n            if (down == 0):\n                tryMove(\"Down\", 0,0.0)\nweststate = 0               \ndef azim_west(west,speed,srvr):\n    global RPC\n    global weststate\n    init_RPC(srvr)\n    if (RPC != None):\n        if (weststate != west):\n            weststate = west\n            if (west == 1):\n                tryMove(\"West\", 1, speed)\n            if (west == 0):\n                tryMove(\"West\", 1, 0.0)\neaststate = 0\ndef azim_east(east,speed,srvr):\n    global RPC\n    global eaststate\n    init_RPC(srvr)\n    if (RPC != None):\n        if (eaststate != east):\n            eaststate = east\n            if (east == 1):\n                tryMove(\"East\", 1, -1.0*speed)\n            if (east == 0):\n                tryMove(\"East\", 1, 0.0)\n\ndef get_posns(pacer,srvr):\n    global RPC2\n    init_RPC2(srvr)\n    try:\n        posns = RPC2.query_both_axes()\n    except:\n        #print (\"get_posns called, but exception was raised\")\n        posns = (-1000, -1000)\n    return(posns)\n\ndef do_heartbeat(pacer,buttons):\n    global RPC\n    if (1 in buttons):\n        try:\n            RPC.HeartBeat(0)\n        except:\n            pass\n    return 1\n\nimport requests\nimport time\ndef pwr_on(val,ipaddr):\n    if (val == 1):\n        try:\n            #print (\"PWR ON with: %d\" % val)\n            r = requests.get('http://%s/30000/03' % ipaddr, timeout=3)\n            time.sleep(0.5)\n            r = requests.get('http://%s/30000/02' % ipaddr, timeout=3)\n        except Exception as e:\n            print (e)\n            pass\n    return True\n\ndef pwr_off(val,ipaddr):\n    if (val == 1):\n        try:\n            #print (\"PWR OFF with: %d\" % val)\n            r = requests.get('http://%s/30000/01' % ipaddr, timeout=3)\n            time.sleep(0.5)\n            r = requests.get('http://%s/30000/00' % ipaddr, timeout=3)\n        except Exception as e:\n            print(e)\n            pass\n    return True\n    \n\n"
  states: {}
- name: import_55
  id: import
  parameters:
    imports: import os
  states: {}
- name: motor_xml
  id: parameter
  parameters:
    label: URL for motor server
    type: str
    value: '"http://localhost:36036"'
  states: {}
- name: pacer_probe
  id: blocks_probe_signal_x
  parameters:
    type: float
  states: {}
- name: pwr_address
  id: parameter
  parameters:
    label: IP Address for power control relay module
    type: str
    value: 192.168.1.4
  states: {}
- name: qss_file
  id: parameter
  parameters:
    label: QSS FILE
    type: str
    value: os.environ['HOME']+"/.qt/"+"dish_ctl.qss"
  states: {}
- name: scadence
  id: parameter
  parameters:
    label: Cadence of sensor query, in seconds
    type: eng_float
    value: '1.0'
  states: {}
- name: sensor_xml
  id: parameter
  parameters:
    label: URL for sensor server
    type: str
    value: '"http://localhost:9090"'
  states: {}
- name: snippet_0
  id: snippet
  parameters:
    code: |-
      dish_funcs.axLimits(0,self.motor_xml)
      dish_funcs.axLimits(1,self.motor_xml)
    section: main_after_init
  states: {}
- name: variable_qtgui_azelplot_0
  id: variable_qtgui_azelplot
  parameters:
    gui_hint: 3,0,3,4
    label: '"Telescope  Position\n                NORTH"'
  states: {state: disabled}

connections:
- [analog_sig_source_x_0, '0', blocks_throttle_0, '0']
- [blocks_message_strobe_0, strobe, variable_qtgui_azelplot_0, azel]
- [blocks_throttle_0, '0', pacer_probe, '0']

metadata:
  file_format: 1
